# Autodesk Inventor part: 289-0.50
## iProperties
Created: 2007-07
Part Number: 289-0.50
Document SubType Name: Modeling
Designer: btaylor
Density: 1 g/cm^3
Author: btaylor
